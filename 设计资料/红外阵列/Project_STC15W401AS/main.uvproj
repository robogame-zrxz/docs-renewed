# Keil uVision project main.uvproj, settings and files
target 目标 1 (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: main +hex
  c flags: SizeSpeed=1
  group 源组 1
    ./: main.c I2C.c
